options:
  parameters:
    author: Aneesh
    generate_options: qt_gui
    id: qamTransmitter
    output_language: python
    title: qamTransmitter
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1+1j, 1-1j, -1+1j, -1-1j, 3+1j, 3-1j, -3+1j, -3-1j, 1+3j, 1-3j, -1+3j, -1-3j, 3+3j, 3-3j, -3+3j, -3-3j]'
    precision: '8'
    soft_dec_lut: '"auto"'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15]'
    type: 16qam
  states: {}
- name: constel_0
  id: variable_constellation
  parameters:
    const_points: '[1+1j, 1-1j, -1+1j, -1-1j, 3+1j, 3-1j, -3+1j, -3-1j, 1+3j, 1-3j, -1+3j, -1-3j, 3+3j, 3-3j, -3+3j, -3-3j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '"auto"'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15]'
    type: calcdist
  states: {state: disabled}
- name: excess_bw
  id: variable
  parameters:
    value: '0.350'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,samp_rate,samp_rate/sps,excess_bw,11*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '13'
    type: byte
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '15'
    min: '0'
    num_samps: '200'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_correctiq_auto_0
  id: blocks_correctiq_auto
  parameters:
    freq: '0'
    gain: '1'
    samp_rate: '4'
    syncWindow: '0.01'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\anees\OneDrive\Documents\SIR\Samples\constelModOutput.bin
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\anees\OneDrive\Documents\SIR\Samples\transmitterInput.bin
    type: byte
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: C:\Users\anees\OneDrive\Documents\SIR\Samples\finalOutput
    type: byte
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: C:\Users\anees\OneDrive\Documents\SIR\Samples\channelModelOutput.bin
    type: complex
  states: {}
- name: blocks_file_sink_4
  id: blocks_file_sink
  parameters:
    file: C:\Users\anees\OneDrive\Documents\SIR\Samples\autosyncOutput.bin
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '4'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: '1'
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1'
    freq_offset: '0.0'
    noise_voltage: '.0001'
    seed: '0'
    taps: '[1.0 + 0j]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.25'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.5'
    ted_type: digital.TED_EARLY_LATE
    type: cc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"QAM Reciever Data Points"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_pack_k_bits_bb_0, '0']
- [analog_random_source_x_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_correctiq_auto_0, '0', blocks_file_sink_4, '0']
- [blocks_correctiq_auto_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_1, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [channels_channel_model_0, '0', blocks_file_sink_3, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_2, '0']
- [digital_constellation_modulator_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_modulator_0, '0', channels_channel_model_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_correctiq_auto_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
